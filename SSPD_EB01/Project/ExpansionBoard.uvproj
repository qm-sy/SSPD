# Keil uVision project ExpansionBoard.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: KP_SSPD_EB01_HW1.0_SW001_20250514 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BSP\Inc;..\Core\Inc;..\Driver;..\Emembed\Inc;..\SYSTEM\Inc
  group Source Group 1
    ./: STARTUP.A51
  group Driver
    ../Driver/: STC8H.h
  group SYSTEM
    ../SYSTEM/Src/: delay.c
  group Core
    ../Core/Src/: gpio.c main.c pwm.c tim.c uart.c
  group BSP
    ../BSP/Src/: communication.c dht11.c power_crl.c level.c
  group Emembed
    ../Emembed/Src/: common.c modbus_rtu.c
